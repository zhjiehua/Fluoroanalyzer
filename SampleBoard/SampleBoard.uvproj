# Keil uVision project SampleBoard.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Fluoroanalyzer_SampleBoard +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\HMI;..\c_project
  group Source Group 1
    ./: STARTUP.A51 main.c uart.c timer.c io.c eeprom.c misc.c management.c ddc112.c
  group HMI
    ./HMI/: cmd_process.c cmd_queue.c hmi_driver.c
